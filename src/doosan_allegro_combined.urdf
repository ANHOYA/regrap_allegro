Commit message: fix: arm_to_hand offset 0.07 → 0.0 (Allegro already has internal offset)

File: src/doosan_allegro_combined.urdf (robot description, URDF)
Before this commit: robot doosan_allegro, 30 links, 29 joints
Joints:
- joint arm_to_hand: origin xyz=0 0 0.07 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
