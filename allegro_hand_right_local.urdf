Commit message: rendering speed 개선

File: allegro_hand_right_local.urdf (robot description, URDF)
Before this commit: robot allegro_hand_right, 22 links, 21 joints
Links:
- link hand_root: mass None -> 0.01; geometry collision box size=0.001 0.001 0.001; visual box size=0.001 0.001 0.001
